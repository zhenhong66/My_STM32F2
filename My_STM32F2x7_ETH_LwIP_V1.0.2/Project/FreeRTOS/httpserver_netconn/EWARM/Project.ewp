# IAR project Project.ewp, settings and files
configuration STM322xG_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32F2x7_ETH_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL; ..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\; ..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; ..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; ..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; ..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; ..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\; ..\..\..\..\Utilities\Third_Party\FreeRTOS_v6.1.0\portable\EWARM\ARM_CM3; ..\..\..\..\Utilities\Third_Party\FreeRTOS_v6.1.0\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../src/: system_stm32f2xx.c
  group EWARM
    ./: startup_stm32f2xx.s
  group FreeRTOS
    ../../../../Utilities/Third_Party/FreeRTOS_v6.1.0/: croutine.c list.c queue.c tasks.c
  group FreeRTOS/portable
    ../../../../Utilities/Third_Party/FreeRTOS_v6.1.0/portable/MemMang/: heap_2.c
    ../../../../Utilities/Third_Party/FreeRTOS_v6.1.0/portable/EWARM/ARM_CM3/: port.c portasm.s
  group LwIP/Api
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/Core
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LwIP/Core/IPv4
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP/Netif
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c
    ../../../../Utilities/Third_Party/lwip_v1.3.2/port/STM32F2x7/FreeRTOS/: ethernetif.c sys_arch.c
  group STM322xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_lcd.c
    ../../../../Utilities/STM32_EVAL/: stm32_eval.c
  group STM32F2x7_ETH_Driver
    ../../../../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM32F2xx_StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_sdio.c stm32f2xx_syscfg.c stm32f2xx_usart.c
  group User
    ../src/: fs.c httpserver-netconn.c main.c netconf.c serial_debug.c stm32f2x7_eth_bsp.c stm32f2xx_it.c
