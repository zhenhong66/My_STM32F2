# Keil uVision project MSD_File.uvproj, settings and files
target MCBSTM32F200 (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: MSD_File
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __STM_EVAL,USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL
  c include: .\;.\FWLib_inc;.\Hardware;.\STM32_EVAL;.\STM32_EVAL\stm322xg_eval
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ./: startup_stm32f2xx.s system_stm32f2xx.c
  group Configuration
    ./: File_Config.c usb_config.c stm32f2xx_it.c
  group Retarget
    ./: Retarget.c
  group Application
    ./: MSD_File.c Getline.c Serial.c fs_usbh_msc.c usbh_stm32f20x.c GLCD_16bitIF_STM32F2xx.c i2c_TSYS01.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib USB_CM3.lib
  group Documentation
    ./: Abstract.txt
  group SWLib
    ./FWLib/: misc.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Hardware
    ./Hardware/: rtc.c
  group STM32_EVAL
    ./STM32_EVAL/: stm32_eval.c
